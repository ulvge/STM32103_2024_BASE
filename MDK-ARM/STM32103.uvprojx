# Keil uVision project STM32103.uvprojx, settings and files
target stm32F103Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;../Middlewares/Third_Party/FreeRTOS/Source/include;..\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\Core\bsp;..\Core\api;..\Core\api\shell;..\Core\api\cm_backtrace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\output\PIC18.sct
  link misc: --keep=*.o(*initcall*)
  group api
    ../Core/api/: api_utc.c FIFO.c print_monitor.c I2CForward.c eeprom.c
  group bsp
    ../Core/bsp/: bsp_uartcomm.c bsp_gpio.c bsp_usart1.c bsp_i2c.c initcall.c pwm.c bsp_i2cs0.c bsp_i2ccomm.c
  group shell
    ../Core/api/shell/: shell.c shell_ext.c shell_port.c gpio_shell.c shell_cmd_list.c
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group cm_backtrace
    ../Core/api/cm_backtrace/: cm_backtrace.c cmb_fault.S
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_exti.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc_ex.c
software components: CMSIS:CORE 5.6.0
